# IAR project boot_app.ewp, settings and files
configuration ram_0x2000 (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1011xxx5A NXP MIMXRT1011xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1011DAE5A
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../xip; ../../../../../devices/MIMXRT1011/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MIMXRT1011; ../../../../../devices/MIMXRT1011/periph; ../../../../../devices/MIMXRT1011/xip; ../../../../../devices/MIMXRT1011/utilities/debug_console_lite; ../../../../../devices/MIMXRT1011/utilities/str; ../../../../../components/uart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1011DAE5A
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: boot_app.bin
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram_0x2000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_iccarm_m.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_COMMON.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group device/periph
    ../../../../../devices/MIMXRT1011/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_OTFAD.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_RTWDOG.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TRNG.h PERI_USB.h PERI_USB_ANALOG.h PERI_USBNC.h PERI_USBPHY.h PERI_WDOG.h PERI_XBARA.h PERI_XTALOSC24M.h
  group doc
    ../: example_board_readme.md readme.md
  group drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pmu.c fsl_pmu.h fsl_src.c fsl_src.h
  group source
    ../: boot_app.c flexspi_nor_flash_ops.c flexspi_nor_polling_transfer.c mcux_config.h
  group startup/iar
    ../../../../../devices/MIMXRT1011/iar/: startup_MIMXRT1011.s
  group utilities
    ../../../../../devices/MIMXRT1011/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../../../../../devices/MIMXRT1011/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
    ../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
